VERSION 5.7 ;
  NOWIREEXTENSIONATPIN ON ;
  DIVIDERCHAR "/" ;
  BUSBITCHARS "[]" ;
MACRO rv328_analog_blank
  CLASS BLOCK ;
  FOREIGN rv328_analog_blank ;
  ORIGIN 0.000 0.000 ;
  SIZE 1405.000 BY 927.000 ;
  OBS
      LAYER Metal1 ;
        RECT 0.000 0.000 1381.000 927.000 ;
      LAYER Metal2 ;
        RECT 0.000 0.000 1381.000 927.000 ;
      LAYER Metal3 ;
        RECT 0.000 0.000 1381.000 927.000 ;
      LAYER Metal4 ;
        RECT 0.000 0.000 1381.000 927.000 ;
      LAYER Metal5 ;
        RECT 0.000 0.000 1381.000 927.000 ;
  END
END rv328_analog_blank
END LIBRARY
